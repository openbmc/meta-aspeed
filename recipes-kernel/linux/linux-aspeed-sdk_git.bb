KBRANCH ?= "aspeed-master-v5.1"
LINUX_VERSION ?= "5.1.3"

SRCREV="f3885751420fa09f177abeecf8e9cb1255124f9b"

require linux-aspeed-sdk.inc
